# Keil uVision project UART_MP3.uvprojx, settings and files
target UART_MP3 (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: GPIO +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\Core\inc;..\Driver;..\Driver\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Core
    ../: UART_MP3.syscfg
    ../Core/src/: main.c oled_spi_V0.2.c Keyboard.c eeprom_emulation_type_a.c UART.c CommandLine.c MusicPlayer.c ti_msp_dl_config.c
    ../Core/inc/: oledfont.h ti_msp_dl_config.h
    ./: startup_mspm0g3507_uvision.s
  group Driver
    ../Driver/ti/driverlib/: dl_adc12.c dl_aes.c dl_common.c dl_crc.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
    ../Driver/ti/driverlib/m0p/: dl_interrupt.c
    ../Driver/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c
